# Keil uVision project spi_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_CUSTOM CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\config;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\boards;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\drivers_nrf\nrf_soc_nosd;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\atomic;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\balloc;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\bsp;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\button;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\delay;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_log;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_log\src;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_memobj;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_section_vars;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\scheduler;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\strerror;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\timer;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\components\libraries\util;..\..\..;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\external\fprintf;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\external\segger_rtt;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\integration\nrfx;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\integration\nrfx\legacy;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\modules\nrfx;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\modules\nrfx\drivers\include;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\modules\nrfx\hal;..\..\..\nRF5_SDK_15.0.0_a53641a\nRF5_SDK_15.0.0_a53641a\modules\nrfx\mdk;..\config
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../: main.c
    ../config/: sdk_config.h custom_board.h
  group Board Definition
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/boards/: boards.c
  group Board Support
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/bsp/: bsp.c
  group nRF_Drivers
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/integration/nrfx/legacy/: nrf_drv_spi.c nrf_drv_uart.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_spi.c nrfx_spim.c nrfx_uart.c nrfx_uarte.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_timer.c
    ../../../nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/integration/nrfx/legacy/: nrf_drv_clock.c
  group nRF_Libraries
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/button/: app_button.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/scheduler/: app_scheduler.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/timer/: app_timer.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/atomic/: nrf_atomic.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/balloc/: nrf_balloc.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_memobj/: nrf_memobj.c
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    D:/biga/nRF5_SDK_15.0.0_a53641a/nRF5_SDK_15.0.0_a53641a/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group enc28j60
    ../enc28j60/: enc28j60.h lc.h lc-switch.h pt.h
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
